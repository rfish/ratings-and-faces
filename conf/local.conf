## conf/local.conf
```bitbake
include "base.conf"
metadata.db.host="localhost"
metadata.db.port=27017
metadata.db.name=metadata

smugmug.nickname=randyfish
```
